require openjdk-8-release-131b12.inc
require openjdk-8-native.inc
