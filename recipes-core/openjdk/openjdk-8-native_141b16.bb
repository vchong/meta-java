require openjdk-8-release-141b16.inc
require openjdk-8-native.inc
